# IAR project AT commands.ewp, settings and files
configuration CoordinatorEB (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: ZIGBEEPRO; NWK_AUTO_POLL; HAL_UART=TRUE; HOLD_AUTO_START; NV_RESTORE; REFLECTOR; HAL_UART_ISR=1; HAL_UART_DMA=2; xHAL_UART_ISR_TX_MAX=200; xPOWER_SAVING; ZCL_READ; ZCL_WRITE; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_DISCOVER; xZTOOL_P1; xMT_TASK; xMT_SYS_FUNC; xMT_ZDO_FUNC; xLCD_SUPPORTED=DEBUG; xMT_UART_DEFAULT_OVERFLOW=FALSE
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\Source\hal; ..\Source\Modified; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\stack\zcl; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration RouterEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZIGBEEPRO; NWK_AUTO_POLL; HAL_UART=TRUE; HOLD_AUTO_START; NV_RESTORE; REFLECTOR; xHAL_UART_ISR_TX_MAX=200; xPOWER_SAVING; ZCL_READ; ZCL_WRITE; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_DISCOVER; HAL_UART_ISR=1; HAL_UART_DMA=2; xZTOOL_P1; xMT_TASK; xMT_SYS_FUNC; xMT_ZDO_FUNC; xLCD_SUPPORTED=DEBUG; xMT_UART_DEFAULT_OVERFLOW=FALSE
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\Source\Modified; ..\Source\hal; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\stack\zcl; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
configuration EndDeviceEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZIGBEEPRO; NWK_AUTO_POLL; HAL_UART=TRUE; HOLD_AUTO_START; NV_RESTORE; REFLECTOR; HAL_UART_ISR=1; HAL_UART_DMA=2; xHAL_UART_ISR_TX_MAX=200; POWER_SAVING; ZCL_READ; ZCL_WRITE; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_DISCOVER; xZTOOL_P1; xMT_TASK; xMT_SYS_FUNC; xMT_ZDO_FUNC; xLCD_SUPPORTED=DEBUG; xMT_UART_DEFAULT_OVERFLOW=FALSE
  group App
    ../Source/: AT_AF.c AT_AF.h AT_App.c AT_App.h AT_uart.c AT_uart.h AT_uart2.c AT_uart2.h AT_ZCL.c AT_ZCL.h AT_ZDO.c AT_ZDO.h
    ./: AT_IR.c AT_IR.h
  group App/app_drivers
    ../Source/: AT_DHT11.c AT_DHT11.h AT_ds18b20.c AT_ds18b20.h AT_printf.c AT_printf.h AT_relay.c AT_relay.h AT_switch.c AT_switch.h AT_switch2.c AT_switch2.h
  group App/AT_ZCL app
    ../Source/: AT_ZCL_DHT.c AT_ZCL_DHT.h AT_ZCL_DHT_data.c AT_ZCL_ONOFF.c AT_ZCL_ONOFF.h AT_ZCL_ONOFF_data.c AT_ZCL_ONOFF_SWITCH.c AT_ZCL_ONOFF_SWITCH.h AT_ZCL_ONOFF_SWITCH2.c AT_ZCL_ONOFF_SWITCH2.h AT_ZCL_ONOFF_SWITCH2_data.c AT_ZCL_ONOFF_SWITCH_data.c AT_ZCL_temperature.c AT_ZCL_temperature.h AT_ZCL_temperature_data.c zcl_ha.c zcl_ha.h
  group App/hal
    ../Source/hal/: hal_board_cfg.h hal_drivers.c hal_drivers.h hal_key.c hal_key.h
  group App/Modified
    ../Source/Modified/: OnBoard.c OnBoard.h
  group App/others
    ../Source/: AT_EXTERN.h At_include.h AT_ONOFF_output.c AT_ONOFF_output.h OSAL_App.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c
  group HAL/Include
    ../../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_flash.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2530EB/Drivers
    ../../../../../Components/hal/target/CC2530EB/: hal_adc.c hal_dma.c hal_flash.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530EB/Includes
    ../../../../../Components/hal/target/CC2530EB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group MT
    ../../../../../Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_DEBUG.c MT_DEBUG.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    ../../../../../Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    ../../../../../Components/stack/sys/: ZGlobals.c ZGlobals.h
  group OSAL
    ../../../../../Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/mcu/cc2530/: OSAL_Math.s51 OSAL_Nv.c
  group Profile
    ../../../../../Components/stack/af/: AF.c AF.h
    ../../../../../Components/stack/zcl/: zcl.c zcl.h zcl_cc.c zcl_cc.h zcl_cert_data.c zcl_closures.c zcl_closures.h zcl_general.c zcl_general.h zcl_gp.h zcl_hvac.c zcl_hvac.h zcl_lighting.c zcl_lighting.h zcl_ms.c zcl_ms.h zcl_pi.c zcl_pi.h zcl_se.c zcl_se.h zcl_ss.c zcl_ss.h
  group Security
    ../../../../../Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
  group Tools
    ../../../Tools/CC2530DB/: f8w2530.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg
  group ZDO
    ../../../../../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../../../../Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../../../../../Components/zmac/: ZMAC.h
  group ZMain
    ../../../ZMain/TI2530DB/: chipcon_cstartup.s51 ZMain.c
